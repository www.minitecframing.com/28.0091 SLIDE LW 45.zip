# Autodesk Inventor assembly: 28.0021 FIXING KIT LRK
## iProperties
Created: 2007-04
Part Number: 28.0021 FIXING KIT LRK
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
