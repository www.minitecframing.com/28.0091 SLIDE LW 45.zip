# Autodesk Inventor assembly: 28.0022 FIXING KIT LRE
## iProperties
Created: 2007-04
Part Number: 28.0022 FIXING KIT LRE
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
