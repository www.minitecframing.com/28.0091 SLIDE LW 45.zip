# Autodesk Inventor assembly: 28.0091 SLIDE LW 45
## iProperties
Created: 2007-04
Part Number: 28.0091 SLIDE LW 45
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
